# Autodesk Inventor part: 7T273-10uzsakovui
## iProperties
Created: 2007-09
Part Number: 7T273-10uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
